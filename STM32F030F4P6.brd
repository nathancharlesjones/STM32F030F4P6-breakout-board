# Repository nathancharlesjones/STM32F030F4P6-breakout-board

File README.md:

# STM32F030F4P6 Breakout Board

# How to order
1. Download or clone this repository.
2. Choose which components you want to include on your breakout board. If it's not one of the prepared arrangements below (Minimum, Standard, or Full), edit the bill of materials ("bom") and assembly files to include only those components that you want. The easiest way to do this is probably to start with the "Full" lists and simply delete the rows of the components you don't want to include.
3. Follow [these instructions for ordering an assembled PCB from JLCPCB or MakerFabs](https://github.com/nathancharlesjones/Embedded-for-Everyone/wiki/3.-Building-a-circuit-on-a-PCB-and-connecting-it-to-the-rest-of-the-embedded-device#ordering-an-assembled-pcb).

# STM32F030F4P6 specifications
|Processor|Core Size|Speed|Connectivity|Peripherals|I/O|Program memory size|RAM size|Data converters|
|---|---|---|---|---|---|---|---|---|
|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART|DMA, POR, PWM, WDT|15|16 kB|4 kB|ADC: 11x 12-bit|

# Pin-compatibility

**WARNING**: I have not checked each of these parts and cannot guarantee that they will work with this board without modifications. They are listed here merely to bring to the reader's attention that there _may_ be pin-compatible STM32 MCUs which _could_ work with this board in the event that the STM32F030F4P6 is not exactly the MCU they would like to use. If you are interested in using one of these other MCUs, I would recommend that you find the appropriate datasheet and hardware development guide from ST Microelectronics to ensure that this board will meet the requirements of any new MCU.

Using the STM32CubeMX tool, it appears to me that, as of this update (18 Dec 2020), this board is also exactly pin-compatible with the MCUs below (the STM32F030F4Px is shown in the first row for comparison).

|Part No.|Processor|Core Size|Speed|Connectivity|Peripherals|I/O|Program memory size|RAM size|Data converters|
|---|---|---|---|---|---|---|---|---|---|
|STM32F030F4Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART|DMA, POR, PWM, WDT|15|16 kB|4 kB|ADC: 11x 12-bit|
|STM32F031F4Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, I2S, POR, PWM, WDT|15|16 kB|4 kB|ADC: 12x 12-bit|
|STM32F031F6Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, I2S, POR, PWM, WDT|15|32 kB|4 kB|ADC: 12x 12-bit|
|STM32F038F6Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, I2S, POR, PWM, WDT|14|32 kB|4 kB|ADC: 9x 12-bit|
|STM32F042F4Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, IrDA, LINbus, USB, CANbus, HDMI-CEC|DMA, I2S, POR, PWM, WDT|16|16 kB|6 kB|ADC: 12x 12-bit|
|STM32F042F6Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, IrDA, LINbus, USB, CANbus, HDMI-CEC|DMA, I2S, POR, PWM, WDT|16|32 kB|6 kB|ADC: 12x 12-bit|
|STM32F070F6Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART, USB|DMA, POR, PWM, WDT|15|32 kB|6 kB|ADC: 11x 12-bit|

The following MCUs are pin-compatible for the purposes of this breakout board (meaning the power, programming, and clock pins line up), but may map their peripherals to different pins than the STM32F030F4P6. From what I could see, it appears as though the only difference is that these MCUs use a different port for the clock pins than the previous MCUs; they will still work as clock pins, but offer slightly different alternate functions than do the MCUs above. The STM32F030F4P6 is shown in the first row (again) for comparison.

|Part No.|Processor|Core Size|Speed|Connectivity|Peripherals|I/O|Program memory size|RAM size|EEPROM size|Data converters|
|---|---|---|---|---|---|---|---|---|---|---|
|STM32F030F4Px|ARM Cortex-M0|32-bit|48 MHz|I2C, SPI, UART/USART|DMA, POR, PWM, WDT|15|16 kB|4 kB|N/A|ADC: 11x 12-bit|
|STM32L010F4Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA|DMA, POR, PWM, WDT, Brown-out detect/reset|16|16 kB|2 kB|128 bytes|ADC: 7x 12-bit|
|STM32L011F3Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA|DMA, POR, PWM, WDT, Brown-out detect/reset|16|8 kB|2 kB|512 bytes|ADC: 9x 12-bit|
|STM32L011F4Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA|DMA, POR, PWM, WDT, Brown-out detect/reset|16|16 kB|2 kB|512 bytes|ADC: 9x 12-bit|
|STM32L031F4Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, POR, PWM, WDT, Brown-out detect/reset|15|16 kB|8 kB|1 kB|ADC: 10x 12-bit|
|STM32L031F6Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, POR, PWM, WDT, Brown-out detect/reset|15|32 kB|8 kB|1 kB|ADC: 10x 12-bit|
|STM32L041F6Px|ARM Cortex-M0+|32-bit|32 MHz|I2C, SPI, UART/USART, IrDA, LINbus|DMA, POR, PWM, WDT, Brown-out detect/reset|15|32 kB|8 kB|1 kB|ADC: 10x 12-bit|

# Schematic

The schematic for this breakout board includes 8 modules or sections:
1. MCU
   - The MCU itself and the 0.1" pin header to which most of the MCU pins are connected (U1 and J1).
2. Power 
   - Power regulator, power filtering capacitors, and an LED indicator (IC1, D1, D2, C1, C2, C3, LED1, and R1).
   - Only C2 and C3 are technically required for MCU operation. If you decide to only include those two components, don't forget to bridge the pads of D1.
   - If IC1 is used, D1 and D2 are strongly recommended, though not technically required. D1 and D2 allow for the MCU to be powered from both the VIN_2.4-3.6V and VIN_5-30V pins at the same time without them damaging each other.
3. Reset
   - The reset button and smoothing capacitor (S1 and C8).
4. BOOT0
   - Selection pin header, current-limiting resistor, and pull-down resistor (J2, R4, and R5)
   - BOOT0 selects which part of the MCU's memory is run at start-up (see [AN4325, Getting started with STM32F030xx and STM32F070xx series
 hardware development](https://www.st.com/content/ccc/resource/technical/document/application_note/91/66/2d/8c/f9/b5/47/55/DM00089834.pdf/files/DM00089834.pdf/jcr:content/translations/en.DM00089834.pdf) for more details).
   - If you **DO** intend to use this feature, leave R5 open.
   - If you **DON'T** intend to use this feature, use a 0 ohm resistor for R5 (or simply short the pads together) to pull BOOT0 to ground.
5. External oscillator
   - Crystal oscillator, load capacitors, and feedback resistor (Y1, C6, C7, and R3)
   - An external crystal oscillator will have higher accuracy than the internal clock, which improves the accuracy of the internal timers and may be necessary for applications such as high-speed UART.
6. Analog voltage reference (VDDA)
   - Diode and power filtering capacitors (D3, C4, and C5)
   - Useful when you want to run the MCU at a lower voltage than what you want your analog voltage reference to be.
   - VDDA **MUST BE** higher than or equal to VDD (hence the diode; it ensures VDDA is at least equal to VDD during power-up/power-down).
   - If you **DON'T** intend to have a separate analog reference voltage, you can leave C4 and C5 off and replace D3 with a 0 ohm resistor (or simply short the pads together). If you do that, be careful not to power the MCU from the VDDA pin in addition to either of the VIN pins. If the power supply voltage on the VIN pins exceeds that of the power supply on the VDDA pin, then the VIN power supply may backpower the VDDA power supply and damage it.
7. User LED
   - LED, current-limiting resistor, and option jumper (LED2, R2, and J3)
   - J3 is used to optionally remove the LED from the circuit, should you wish to not have the LED connected to its GPIO.
   - To remove LED2 from the circuit, cut the trace between the terminals of J3 on TOP of the PCB (where its marked on the silkscreen).
   - To reinsert LED2, place a pin header and jumper in J3. The jumper now controls whether LED2 is included in the circuit or not.
8. J-Link connector (J4)

## Minimum components
- Cost: Approximately $2.60 per board on JLCPCB (in quantities of 10)
- The minimum components required for the MCU to operate plus a reset button, power LED, and user LED.
- Includes:
   - STM32F030F4P6 (U1)
   - Power filtering capacitors (C2, C3)
   - Reset circuit (C8, S1)
   - Power LED (LED1, R1)
   - User LED (LED2, R2)
   - BOOT0 current-limiting resistor (R4)
- User must short the pads of (separately) D1, D3, and R5.
- Constraints:
   - Analog reference voltage (VDDA) is equal to the power supply voltage (VDDA)
   - Power supply voltage must be 2.4-3.6V
   - BOOT0 fixed at 0 (unless a logical 1 is present on the BOOT0 pin on J1)
   - No external oscillator

## Standard components
- Cost: Approximately $3.00 per board on JLCPCB (in quantities of 10)
- The components most likely to be needed for a typical application.
- Includes:
   - STM32F030F4P6 (U1)
   - Power regulator, power filtering capacitors, and blocking diodes (IC1, C1, C2, C3, D1, D2)
   - Reset circuit (C8, S1)
   - Power LED (LED1, R1)
   - User LED (LED2, R2)
   - BOOT0 current-limiting resistor and pull-down resistor (R4, R5)
   - External oscillator (Y1, C6, C7, R3)
   - Shorting resistor across D3
- Power supply can be 2.4-3.6V (on VIN_2.4-3.6V) or 5-30V (on VIN_5-30V)
- User doesn't have to short any pads together (all accomplished with two 0 ohm resistors, R5 and "D3")
- Constraints:
   - Analog reference voltage (VDDA) is equal to the power supply voltage (VDDA)
   - BOOT0 fixed at 0 (unless a logical 1 is present on the BOOT0 pin on J1)

## Full components
- Cost: Approximately $3.00 per board on JLCPCB (in quantities of 10)
- Includes all components on the breakout board:
   - STM32F030F4P6 (U1)
   - Power regulator, power filtering capacitors, and blocking diodes (IC1, C1, C2, C3, D1, D2)
   - Reset circuit (C8, S1)
   - Power LED (LED1, R1)
   - User LED (LED2, R2)
   - BOOT0 current-limiting resistor (R4), **NO** shorting resistor
   - External oscillator (Y1, C6, C7, R3)
   - Analog voltage reference diode and power filtering capacitors (D3, C4, C5)
- Power supply can be 2.4-3.6V (on VIN_2.4-3.6V) or 5-30V (on VIN_5-30V)
- User must populate J2 with a pin header and jumper in order to select the proper BOOT0 configuration
- Board may, but is not required to, run a separate power supply voltage and analog reference voltage.

# PCB Silkscreen Text
> - VIN, 2.4-3.6V: MCU damage may occur if >4V
> - Max current, ea pin: 25 mA
> - Mx current, all pins: 80 mA
> - USER LED on A0 (pin 6); Cut trace btwn J3 on TOP of PCB to remove LED (in-stall jumper to reinsert)
>--------------------
> - U1: STM32F030F4P6
> - IC1: 2.4-3.6V regulator, >=100mA / SOT-89-3 (ex: LCSC part# C14289)
> - Y1: 8MHz resonator / 5x3.2mm (ex: LCSC part# C115962)
> - J2: J-Link connector (ex: HPH2-A-10-UA from Adam Tech or 3220-10 -0100-00 from CNC Tech)
> - All footprints other parts 0603 unless noted.
> - C1: 10uF        | C2: 4.7uF
> - C3, C8: 100nF   | C4: 1uF
> - C6, C7: 20pF    | C5: 10nF
> - R5: 0R (pulls BOOT0 to GND if J2 is not used)
> - R3: 1k
> - R1, R2: ~100R   | R4: 10k
> - S1: SPST-NO / 5.1mmx5.1mm (ex: LCSC part# C318884)
> - D1, D2: Shottky / SOD-123
> - D3: Shottky / DO-214AC (short if VDDA = VDD)
> - FMI: github.com/nathancharlesjones/Embedded-for-Everyone/wiki

# References
- [STM32F030F4 product page](https://www.st.com/content/st_com/en/products/microcontrollers-microprocessors/stm32-32-bit-arm-cortex-mcus/stm32-mainstream-mcus/stm32f0-series/stm32f0x0-value-line/stm32f030f4.html)
- [AN4325, Getting started with STM32F030xx and STM32F070xx series
 hardware development](https://www.st.com/content/ccc/resource/technical/document/application_note/91/66/2d/8c/f9/b5/47/55/DM00089834.pdf/files/DM00089834.pdf/jcr:content/translations/en.DM00089834.pdf)
- [DS9773](https://www.st.com/resource/en/datasheet/stm32f030f4.pdf), STM32F030F4P6 datasheet
- [RM0360](https://www.st.com/resource/en/reference_manual/dm00091010.pdf), STM32F030F4P6 reference manual

## EAGLE design STM32F030F4P6.brd

Parts:
C1: 10uF; C0603
C2: 4.7uF; C0603
C3, C8: 100nF; C0603
C4: 1uF; C0603
C5: 10nF; C0603
C6, C7: 20pF; C0603
D1, D2: DIODESOD-123; SOD-123
D3: DIODE-DO-214AC; DO-214AC
FRAME2: FRAME-LETTERNO_PACKAGE; DUMMY
IC1: MCP170333MB; SOT89
J1: CONN_19; 1X19
J2: 455-1750-1-ND; 1X03
J3: CONN_02; 1X02
J4: CORTEX_DEBUG_MINIMUM_PTH; 2X5-PTH-1.27MM
LED1, LED2: LEDCHIPLED_0603; CHIPLED_0603
R1, R2: 100R; R0603
R3: 1k; R0603
R4: 10k; R0603
R5: 0R; R0603
S1: MOMENTARY-SWITCH-SPST-SMD-5.2-REDUNDANT; TACTILE_SWITCH_SMD_5.2MM
U1: STM32F030F4P6; SOP65P640X120-20N
Y1: CRYSTALSMD-5X3.2-2PAD; CRYSTAL-SMD-5X3.2-2PAD

Connections:
A0: J1.3, LED2.A, U1.6 (PA0/USART1_CTS/ADC_IN0/RTC_TAMP2/WKUP1)
A1: J1.4, U1.7 (PA1/USART1_RTS/EVENTOUT/ADC_IN1)
A2: J1.5, U1.8 (PA2/USART1_TX/ADC_IN2)
A3: J1.6, U1.9 (PA3/USART1_RX/ADC_IN3)
A4: J1.7, U1.10 (PA4/SPI1_NSS/USART1_CK/TIM14_CH1/ADC_IN4)
A5: J1.8, U1.11 (PA5/SPI1_SCK/ADC_IN5)
A6: J1.9, U1.12 (PA6/SPI1_MISO/TIM3_CH1/TIM1_BKIN/TIM16_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)
A7: J1.10, U1.13 (PA7/SPI1_MOSI/TIM3_CH2/TIM14_CH1/TIM1_C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)
A9: J1.12, U1.17 (PA9/USART1_TX/TIM1_CH2/I2C1_SCL)
A10: J1.13, U1.18 (PA10/USART1_RX/TIM1_CH3/TIM17_BKIN/I2C1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)
B1: J1.11, U1.14 (PB1/TIM3_CH4/TIM14_CH1/TIM1_CH3N/ADC_IN9)
BOOT0: J1.1, R4.2, U1.1 (BOOT0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC1.1 (GND), J1.17, J2.1, J4.3 (GND), J4.5 (GND), J4.9 (GND), R1.1, R2.2, R5.1, S1.1, S1.2 (1), U1.15 (VSS)
unnamed: J2.2, R4.1, R5.2
unnamed: J3.1, J3.2, LED2.C, R2.1
unnamed: C6.1, R3.1, Y1.P$1 (1)
unnamed: D2.A, IC1.3 (VO)
unnamed: LED1.C, R1.2
NRST: C8.1, J1.14, J4.10 (!RESET), S1.3 (2), S1.4 (2), U1.4 (NRST)
OSC_IN: C7.1, U1.2 (PF0/OSC_IN), Y1.P$2 (2)
OSC_OUT: R3.2, U1.3 (PF1/OSC_OUT)
SWCLK: J1.16, J4.4 (SWDCLK), U1.20 (PA14/USART1_TX/SWCLK)
SWDIO: J1.15, J4.2 (SWDIO), U1.19 (PA13/IR_OUT/SWDIO)
VDD: C2.1, C3.1, D1.C, D2.C, D3.A, J2.3, J4.1 (VCC), LED1.A, U1.16 (VDD)
VDDA: C4.1, C5.1, D3.C, J1.2, U1.5 (VDDA)
VIN_2.4-3.6V: D1.A, J1.18
VIN_5-30V: C1.1, IC1.2@1 (VI1), J1.19

Board: 2 copper layers, 20.3 x 50.8 mm, 27 parts (0 on the bottom side), 27 nets.

File bom_Minimum.csv:

Comment,Designator,Footprint,LCSC part#
4.7uF,C2,C0603,C19666
100nF,"C3, C8",C0603,C14663
,"LED1, LED2",CHIPLED_0603,C84256
100R,"R1, R2",R0603,C22775
10k,R4,R0603,C25804
0R,R5,R0603,C21189
MOMENTARY-SWITCH-SPST-SMD-5.2-REDUNDANT,S1,TACTILE_SWITCH_SMD_5.2MM,C318884
STM32F030F4P6,U1,SOP65P640X120-20N,C89040

## Commit log

2020-03-08 Initial commit.
2020-03-08 Made inline.
2020-03-08 Added J-Link connector.
2020-03-08 Added capacitors, resistors, diodes, LEDs.
2020-03-08 Added capacitors, resistors, diodes, LEDs, and J-Link connector.
2020-03-08 Connected all components.
2020-03-08 Initial layout, placing VDD capacitors and HSE oscillator in close proximity to their respective pins.
2020-03-08 Initial placement. Added diode between VDD and VDDA. Added pulldown resistor to BOOT0.
2020-03-09 Finished.
2020-03-09 Cleaned up silkcreen and checked rotation of parts on JLCPCB.
2020-03-11 Added gitignore file to exclude hidden lock files.
2020-03-11 Removed lock files from being tracked.
2020-03-12 Added schematic PDF and PNG and README.
2020-03-12 Updated README.
2020-03-12 Added PCB image. Updated README.
2020-03-12 Changed title of schematic image.
2020-03-30 Checking for loose files.
2020-12-18 Added pin compatibility check and info to README.
2020-12-19 Updated pin-compatible MCUs.
2020-12-21 Removed extraneous board/schematic files.

Notices in the files:
parts and their libraries:
SparkFun-Connectors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
